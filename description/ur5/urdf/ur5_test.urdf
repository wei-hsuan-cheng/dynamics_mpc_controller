Commit message: Update ur5 urdf

File: description/ur5/urdf/ur5_test.urdf (robot description, URDF)
Before this commit: robot ur5, 13 links, 12 joints
Joints:
- joint world_to_base_joint: origin xyz=0 0 0.05 rpy=0 0 0 -> xyz=0 0 0.0 rpy=0 0 0
